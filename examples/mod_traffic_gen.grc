options:
  parameters:
    generate_options: qt_gui
    id: modulated_traffic_gen
    output_language: python
    title: Modulated Traffic Generator
  states: {}

blocks:
- name: const_QAM16
  id: variable_constellation
  parameters:
    const_points: '[(-3-3j), (-1-3j), (1-3j), (3-3j), (-3-1j), (-1-1j), (1-1j), (3-1j), (-3+1j), (-1+1j), (1+1j), (3+1j), (-3+3j), (-1+3j), (1+3j), (3+3j)]'
    precision: '8'
    sym_map: '[0, 4, 12, 8, 1, 5, 13, 9, 3, 7, 15, 11, 2, 6, 14, 10]'
    type: 16qam
  states: {}
- name: freq_am_ssb
  id: variable
  parameters:
    value: '1000'
  states: {state: disabled}
- name: margin
  id: variable
  parameters:
    value: '3000'
  states: {}
- name: psk2
  id: variable
  parameters:
    value: digital.psk.psk_constellation(m=2, mod_code='none', differential=True)
  states: {}
- name: psk4
  id: variable
  parameters:
    value: digital.psk.psk_constellation(m=4, mod_code='none', differential=True)
  states: {}
- name: psk8
  id: variable
  parameters:
    value: digital.psk.psk_constellation(m=8, mod_code='none', differential=True)
  states: {}
- name: qam16
  id: variable
  parameters:
    value: digital.qam.qam_constellation(constellation_points=16, differential=True, mod_code='none', large_ampls_to_corners=False)
  states: {}
- name: qam256
  id: variable
  parameters:
    value: digital.qam.qam_constellation(constellation_points=256, differential=True, mod_code='none', large_ampls_to_corners=False)
  states: {}
- name: qam64
  id: variable
  parameters:
    value: digital.qam.qam_constellation(constellation_points=64, differential=True, mod_code='none', large_ampls_to_corners=False)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: tag_length
  id: variable
  parameters:
    value: '"traffic_length"'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    comment: FSK2
    sensitivity: '1'
  states: {}
- name: analog_frequency_modulator_fc_0_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: '1'
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: samp_rate
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: '0'
    tau: '75e-6'
  states: {state: disabled}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: analog_random_source_x_0_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: int
  states: {}
- name: analog_random_source_x_0_0_0
  id: analog_random_source_x
  parameters:
    max: '4'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: int
  states: {}
- name: analog_random_source_x_0_1
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: int
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq_am_ssb
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: audio_source_0_0
  id: audio_source
  parameters:
    device_name: hw:CARD=PCH,DEV=0
    samp_rate: samp_rate
  states: {state: disabled}
- name: blocks_int_to_float_0
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_int_to_float_0_0
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_int_to_float_0_0_0
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_magphase_to_complex_0
  id: blocks_magphase_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    num_inputs: '4'
    type: complex
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: complex
  states: {}
- name: blocks_tagged_stream_to_pdu_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: complex
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: const_QAM16.points()
  states: {}
- name: digital_gmsk_mod_0
  id: digital_gmsk_mod
  parameters:
    bt: '0.35'
    samples_per_symbol: '2'
  states: {}
- name: high_pass_filter_0
  id: high_pass_filter
  parameters:
    cutoff_freq: freq_am_ssb
    gain: '1'
    interp: '1'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: freq_am_ssb/10
    win: firdes.WIN_HAMMING
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: from gnuradio import digital
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"DSB"'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"SSB"'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: traffic_gen_margin_cut_0
  id: traffic_gen_margin_cut
  parameters:
    end_margin: margin
    head_margin: margin
    tag_name: tag_length
    zero_fill: 'True'
  states: {}
- name: traffic_gen_mmse_resampler_cc_0
  id: traffic_gen_mmse_resampler_cc
  parameters:
    phase_shift: '0'
    resamp_ratio: '1'
    type: complex
  states: {}
- name: traffic_gen_trigger_0
  id: traffic_gen_trigger
  parameters:
    ip_addr: 127.0.0.1
    margin: margin
    port: '7000'
    tag_name: tag_length
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_magphase_to_complex_0, '1']
- [analog_frequency_modulator_fc_0, '0', blocks_null_sink_0_0, '0']
- [analog_frequency_modulator_fc_0_0, '0', blocks_null_sink_0_0, '1']
- [analog_random_source_x_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [analog_random_source_x_0, '0', digital_gmsk_mod_0, '0']
- [analog_random_source_x_0_0, '0', blocks_int_to_float_0, '0']
- [analog_random_source_x_0_0_0, '0', blocks_int_to_float_0_0, '0']
- [analog_random_source_x_0_1, '0', blocks_int_to_float_0_0_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [audio_source_0_0, '0', analog_nbfm_tx_0, '0']
- [audio_source_0_0, '0', blocks_multiply_xx_0, '0']
- [audio_source_0_0, '0', qtgui_time_sink_x_1, '0']
- [audio_source_0_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_int_to_float_0, '0', analog_frequency_modulator_fc_0, '0']
- [blocks_int_to_float_0_0, '0', analog_frequency_modulator_fc_0_0, '0']
- [blocks_int_to_float_0_0_0, '0', blocks_magphase_to_complex_0, '0']
- [blocks_magphase_to_complex_0, '0', blocks_null_sink_0_0, '2']
- [blocks_multiply_xx_0, '0', high_pass_filter_0, '0']
- [blocks_pdu_to_tagged_stream_0, '0', blocks_null_sink_0, '0']
- [blocks_pdu_to_tagged_stream_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_tagged_stream_to_pdu_0, pdus, blocks_pdu_to_tagged_stream_0, pdus]
- [digital_chunks_to_symbols_xx_0, '0', traffic_gen_trigger_0, '0']
- [digital_gmsk_mod_0, '0', blocks_null_sink_0_0, '3']
- [high_pass_filter_0, '0', qtgui_time_sink_x_1, '1']
- [high_pass_filter_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [traffic_gen_margin_cut_0, '0', blocks_tagged_stream_to_pdu_0, '0']
- [traffic_gen_mmse_resampler_cc_0, '0', traffic_gen_margin_cut_0, '0']
- [traffic_gen_trigger_0, '0', traffic_gen_mmse_resampler_cc_0, '0']

metadata:
  file_format: 1
