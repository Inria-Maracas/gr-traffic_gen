options:
  parameters:
    author: cyrille
    generate_options: qt_gui
    id: tx_graph
    output_language: python
    title: Transmitter
  states: {}

blocks:
- name: margin
  id: variable_qtgui_range
  parameters:
    label: Margin
    start: '0'
    step: '1'
    stop: '1000'
    value: '50'
  states: {}
- name: qam_const
  id: variable_constellation
  parameters:
    precision: '8'
    type: 16qam
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '20'
    type: complex
  states: {state: disabled}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: 2**4
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.001'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_burst_tagger_0
  id: blocks_burst_tagger
  parameters:
    false_key: burt
    false_value: 'False'
    true_key: burt
    true_value: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '100'
  states: {state: disabled}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '10'
    max_iter: '4000'
    scale: 1/10
    type: float
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '0.01'
  states: {state: disabled}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_chunks_to_symbols_xx_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: qam_const.points()
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    tr_chan: '2'
    tr_delay: 1*(160/samp_rate)
    tr_level: '0.15'
    tr_tag: '"burt"'
    type: complex
  states: {}
- name: traffic_gen_insert_burst_0
  id: traffic_gen_insert_burst
  parameters: {}
  states: {}
- name: traffic_gen_mmse_resampler_cc_0
  id: traffic_gen_mmse_resampler_cc
  parameters:
    phase_shift: '0'
    resamp_ratio: '0.5'
    type: complex
  states: {}
- name: traffic_gen_trigger_0
  id: traffic_gen_trigger
  parameters:
    ip_addr: 127.0.0.1
    margin: margin
    port: '7000'
    tag_name: start_pack
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_throttle_0, '0']
- [analog_random_source_x_0, '0', digital_chunks_to_symbols_xx_0_0, '0']
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_burst_tagger_0, '0', blocks_tag_debug_0, '0']
- [blocks_burst_tagger_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_float_to_short_0, '0', blocks_burst_tagger_0, '1']
- [blocks_float_to_short_0, '0', blocks_short_to_float_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_float_to_complex_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_float_to_complex_0, '1']
- [blocks_moving_average_xx_0, '0', blocks_float_to_short_0, '0']
- [blocks_null_source_0, '0', blocks_throttle_0, '0']
- [blocks_short_to_float_0, '0', blocks_float_to_complex_0, '0']
- [blocks_short_to_float_0, '0', blocks_float_to_complex_0, '1']
- [blocks_throttle_0, '0', traffic_gen_insert_burst_0, '0']
- [digital_chunks_to_symbols_xx_0_0, '0', traffic_gen_trigger_0, '0']
- [traffic_gen_insert_burst_0, '0', blocks_burst_tagger_0, '0']
- [traffic_gen_insert_burst_0, '0', blocks_complex_to_mag_squared_0, '0']
- [traffic_gen_insert_burst_0, '0', blocks_tag_debug_0, '0']
- [traffic_gen_insert_burst_0, '0', qtgui_time_sink_x_0, '0']
- [traffic_gen_mmse_resampler_cc_0, '0', traffic_gen_insert_burst_0, '1']
- [traffic_gen_trigger_0, '0', traffic_gen_mmse_resampler_cc_0, '0']

metadata:
  file_format: 1
