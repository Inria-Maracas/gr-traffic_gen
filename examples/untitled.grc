options:
  parameters:
    author: cyrille
    generate_options: qt_gui
    id: tx_graph
    output_language: python
    title: Transmitter
  states: {}

blocks:
- name: const_QAM16
  id: variable_constellation
  parameters:
    const_points: '[(-3-3j), (-1-3j), (1-3j), (3-3j), (-3-1j), (-1-1j), (1-1j), (3-1j), (-3+1j), (-1+1j), (1+1j), (3+1j), (-3+3j), (-1+3j), (1+3j), (3+3j)]'
    precision: '8'
    sym_map: '[0, 4, 12, 8, 1, 5, 13, 9, 3, 7, 15, 11, 2, 6, 14, 10]'
    type: 16qam
  states: {}
- name: filename
  id: variable
  parameters:
    value: '"exemple_1"'
  states: {}
- name: margin
  id: variable_qtgui_range
  parameters:
    label: Margin
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '1000'
    value: '250'
  states: {}
- name: qam256
  id: variable
  parameters:
    value: digital.qam.qam_constellation(constellation_points=256, differential=True, mod_code='none', large_ampls_to_corners=False)
  states: {}
- name: qam64
  id: variable
  parameters:
    value: digital.qam.qam_constellation(constellation_points=64, differential=True, mod_code='none', large_ampls_to_corners=False)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: tagname
  id: variable
  parameters:
    value: '"start_pack"'
  states: {}
- name: total_sample
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '20'
    type: complex
  states: {state: disabled}
- name: analog_const_source_x_1
  id: analog_const_source_x
  parameters:
    const: '0'
    type: complex
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0.01'
    noise_type: analog.GR_UNIFORM
    seed: '0'
    type: complex
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: 2**4
    min: '0'
    num_samps: '100000'
    repeat: 'True'
    type: byte
  states: {}
- name: analog_random_source_x_0_0
  id: analog_random_source_x
  parameters:
    max: 2**4
    min: '0'
    num_samps: '100000'
    repeat: 'True'
    type: byte
  states: {}
- name: analog_random_source_x_0_0_0
  id: analog_random_source_x
  parameters:
    max: 2**4
    min: '0'
    num_samps: '100000'
    repeat: 'True'
    type: byte
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '4'
    type: complex
  states: {}
- name: blocks_burst_tagger_0
  id: blocks_burst_tagger
  parameters:
    false_key: burt
    false_value: 'False'
    true_key: burt
    true_value: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: /root/test
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: output
    type: complex
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '100'
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '0.01'
  states: {state: disabled}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_tag_debug_1
  id: blocks_tag_debug
  parameters:
    name: end
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_1_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_1_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: bypassed}
- name: blocks_throttle_1_0_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: bypassed}
- name: blocks_throttle_1_0_0_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: bypassed}
- name: blocks_throttle_1_0_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_1_0_1_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_chunks_to_symbols_xx_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: const_QAM16.points()
  states: {}
- name: digital_chunks_to_symbols_xx_0_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: qam64.points()
  states: {}
- name: digital_chunks_to_symbols_xx_0_0_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: qam256.points()
  states: {}
- name: epy_block_0_1_0_0_0_0_0_0_0_0_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, name = "triger"):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Eval_number_sample',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.m_name = name
              self.count = 0

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              self.count += len(input_items[0])
              print("%s-%s-%s\n" % (self.m_name, len(input_items[0]), self.count))
              self.consume(0,len(input_items[0])) 
              return 0
    name: '"noise"'
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    name: '"Burst Source"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Signal Source"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    name: '"Source"'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_3
  id: qtgui_time_sink_x
  parameters:
    name: '"Margin CuT"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Resampler"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"resamp"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"FINAL"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: traffic_gen_gate_0
  id: traffic_gen_gate
  parameters:
    total_number_of_sample: total_sample
  states: {}
- name: traffic_gen_insert_burst_0
  id: traffic_gen_insert_burst
  parameters:
    end_margin: margin
    tag_name: tagname
    zero_fill: 'True'
  states: {}
- name: traffic_gen_insert_burst_0_0
  id: traffic_gen_insert_burst
  parameters:
    end_margin: margin
    tag_name: tagname
    zero_fill: 'True'
  states: {}
- name: traffic_gen_insert_burst_0_0_0
  id: traffic_gen_insert_burst
  parameters:
    end_margin: margin
    tag_name: tagname
    zero_fill: 'True'
  states: {}
- name: traffic_gen_labelisator_0
  id: traffic_gen_labelisator
  parameters:
    file_name: filename
    head_margin: margin
    number_of_samples: '1000000'
    tag_name: tagname
  states: {state: disabled}
- name: traffic_gen_labelisator_1
  id: traffic_gen_labelisator
  parameters:
    file_name: filename
    head_margin: margin
    number_of_samples: total_sample
    tag_name: tagname
  states: {}
- name: traffic_gen_margincut_0
  id: traffic_gen_margincut
  parameters:
    end_margin: margin
    head_margin: margin
    tag_name: tagname
    zero_fill: 'True'
  states: {}
- name: traffic_gen_margincut_0_0
  id: traffic_gen_margincut
  parameters:
    end_margin: margin
    head_margin: margin
    tag_name: tagname
    zero_fill: 'True'
  states: {}
- name: traffic_gen_margincut_0_0_0
  id: traffic_gen_margincut
  parameters:
    end_margin: margin
    head_margin: margin
    tag_name: tagname
    zero_fill: 'True'
  states: {}
- name: traffic_gen_mmse_resampler_cc_0
  id: traffic_gen_mmse_resampler_cc
  parameters:
    phase_shift: '0'
    resamp_ratio: '1'
    tag_name: tagname
    type: complex
  states: {}
- name: traffic_gen_mmse_resampler_cc_0_0
  id: traffic_gen_mmse_resampler_cc
  parameters:
    phase_shift: '0'
    resamp_ratio: '1'
    tag_name: tagname
    type: complex
  states: {}
- name: traffic_gen_mmse_resampler_cc_0_0_0
  id: traffic_gen_mmse_resampler_cc
  parameters:
    phase_shift: '0'
    resamp_ratio: '1'
    tag_name: tagname
    type: complex
  states: {}
- name: traffic_gen_trigger_0
  id: traffic_gen_trigger
  parameters:
    ip_addr: 127.0.0.1
    margin: margin
    modulation_id: '0'
    modulation_name: qam16
    port: '7000'
    samp_rate: samp_rate
    tag_name: tagname
  states: {}
- name: traffic_gen_trigger_0_0
  id: traffic_gen_trigger
  parameters:
    ip_addr: 127.0.0.1
    margin: margin
    modulation_id: '1'
    modulation_name: qam64
    port: '7000'
    samp_rate: samp_rate
    tag_name: tagname
  states: {}
- name: traffic_gen_trigger_0_0_0
  id: traffic_gen_trigger
  parameters:
    ip_addr: 127.0.0.1
    margin: margin
    modulation_id: '2'
    modulation_name: qam256
    port: '7000'
    samp_rate: samp_rate
    tag_name: tagname
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: const_source
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: const_noise
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: const_source
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: const_source
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: const_source
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: const_noise
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_throttle_0, '0']
- [analog_const_source_x_1, '0', blocks_throttle_0, '0']
- [analog_noise_source_x_0, '0', blocks_throttle_1, '0']
- [analog_noise_source_x_0, '0', epy_block_0_1_0_0_0_0_0_0_0_0_1, '0']
- [analog_random_source_x_0, '0', digital_chunks_to_symbols_xx_0_0, '0']
- [analog_random_source_x_0_0, '0', digital_chunks_to_symbols_xx_0_0_0, '0']
- [analog_random_source_x_0_0_0, '0', digital_chunks_to_symbols_xx_0_0_0_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '1']
- [analog_sig_source_x_0_1, '0', blocks_multiply_xx_0_1, '1']
- [blocks_add_xx_0, '0', traffic_gen_gate_0, '0']
- [blocks_burst_tagger_0, '0', blocks_tag_debug_0, '0']
- [blocks_float_to_short_0, '0', blocks_burst_tagger_0, '1']
- [blocks_float_to_short_0, '0', blocks_short_to_float_0, '0']
- [blocks_multiply_xx_0, '0', blocks_throttle_1_0_1, '0']
- [blocks_multiply_xx_0_0, '0', blocks_throttle_1_0, '0']
- [blocks_multiply_xx_0_1, '0', blocks_throttle_1_0_1_0, '0']
- [blocks_null_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', virtual_sink_0, '0']
- [blocks_throttle_1, '0', virtual_sink_0_0, '0']
- [blocks_throttle_1_0, '0', blocks_add_xx_0, '0']
- [blocks_throttle_1_0_0, '0', traffic_gen_insert_burst_0, '1']
- [blocks_throttle_1_0_0_0, '0', traffic_gen_insert_burst_0_0, '1']
- [blocks_throttle_1_0_0_0_0, '0', traffic_gen_insert_burst_0_0_0, '1']
- [blocks_throttle_1_0_1, '0', blocks_add_xx_0, '1']
- [blocks_throttle_1_0_1_0, '0', blocks_add_xx_0, '2']
- [digital_chunks_to_symbols_xx_0_0, '0', qtgui_time_sink_x_1_0, '0']
- [digital_chunks_to_symbols_xx_0_0, '0', qtgui_time_sink_x_2, '1']
- [digital_chunks_to_symbols_xx_0_0, '0', traffic_gen_trigger_0, '0']
- [digital_chunks_to_symbols_xx_0_0_0, '0', traffic_gen_trigger_0_0, '0']
- [digital_chunks_to_symbols_xx_0_0_0_0, '0', traffic_gen_trigger_0_0_0, '0']
- [traffic_gen_gate_0, '0', blocks_file_sink_1, '0']
- [traffic_gen_gate_0, '0', blocks_tag_debug_1, '0']
- [traffic_gen_gate_0, '0', qtgui_waterfall_sink_x_1, '0']
- [traffic_gen_gate_0, '0', traffic_gen_labelisator_0, '0']
- [traffic_gen_gate_0, '0', traffic_gen_labelisator_1, '0']
- [traffic_gen_insert_burst_0, '0', blocks_file_sink_0, '0']
- [traffic_gen_insert_burst_0, '0', blocks_multiply_xx_0_0, '0']
- [traffic_gen_insert_burst_0, '0', qtgui_waterfall_sink_x_0_1, '0']
- [traffic_gen_insert_burst_0_0, '0', blocks_multiply_xx_0, '0']
- [traffic_gen_insert_burst_0_0_0, '0', blocks_multiply_xx_0_1, '0']
- [traffic_gen_margincut_0, '0', blocks_throttle_1_0_0, '0']
- [traffic_gen_margincut_0, '0', qtgui_time_sink_x_3, '0']
- [traffic_gen_margincut_0_0, '0', blocks_throttle_1_0_0_0, '0']
- [traffic_gen_margincut_0_0_0, '0', blocks_throttle_1_0_0_0_0, '0']
- [traffic_gen_mmse_resampler_cc_0, '0', qtgui_waterfall_sink_x_0, '0']
- [traffic_gen_mmse_resampler_cc_0, '0', traffic_gen_margincut_0, '0']
- [traffic_gen_mmse_resampler_cc_0_0, '0', traffic_gen_margincut_0_0, '0']
- [traffic_gen_mmse_resampler_cc_0_0_0, '0', traffic_gen_margincut_0_0_0, '0']
- [traffic_gen_trigger_0, '0', traffic_gen_mmse_resampler_cc_0, '0']
- [traffic_gen_trigger_0, freq, analog_sig_source_x_0_0, freq]
- [traffic_gen_trigger_0_0, '0', traffic_gen_mmse_resampler_cc_0_0, '0']
- [traffic_gen_trigger_0_0, freq, analog_sig_source_x_0, freq]
- [traffic_gen_trigger_0_0_0, '0', traffic_gen_mmse_resampler_cc_0_0_0, '0']
- [traffic_gen_trigger_0_0_0, freq, analog_sig_source_x_0_1, freq]
- [virtual_source_0, '0', traffic_gen_insert_burst_0, '0']
- [virtual_source_0_0, '0', traffic_gen_insert_burst_0_0, '0']
- [virtual_source_0_0_0, '0', traffic_gen_insert_burst_0_0_0, '0']
- [virtual_source_0_1, '0', blocks_add_xx_0, '3']

metadata:
  file_format: 1
