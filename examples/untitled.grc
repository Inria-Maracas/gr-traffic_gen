options:
  parameters:
    author: cyrille
    generate_options: qt_gui
    id: testing_pdu
    output_language: python
    title: Testing PDU utils
  states: {}

blocks:
- name: margin
  id: variable_qtgui_range
  parameters:
    label: Margin
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: qam_const
  id: variable_constellation
  parameters:
    precision: '8'
    type: 16qam
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: 2**4
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: complex
  states: {}
- name: digital_chunks_to_symbols_xx_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: qam_const.points()
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '160'
    srate: samp_rate
    tr_delay: 0.1*(160/samp_rate)
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"start_pack"'
    type: complex
  states: {}
- name: traffic_gen_mmse_resampler_cc_0
  id: traffic_gen_mmse_resampler_cc
  parameters:
    phase_shift: '0'
    resamp_ratio: '0.5'
    type: complex
  states: {}
- name: traffic_gen_trigger_0
  id: traffic_gen_trigger
  parameters:
    ip_addr: 127.0.0.1
    margin: margin
    port: '7000'
    tag_name: start_pack
  states: {}

connections:
- [analog_random_source_x_0, '0', digital_chunks_to_symbols_xx_0_0, '0']
- [digital_chunks_to_symbols_xx_0_0, '0', traffic_gen_trigger_0, '0']
- [traffic_gen_mmse_resampler_cc_0, '0', blocks_tag_debug_0, '0']
- [traffic_gen_mmse_resampler_cc_0, '0', qtgui_time_sink_x_0, '0']
- [traffic_gen_trigger_0, '0', traffic_gen_mmse_resampler_cc_0, '0']

metadata:
  file_format: 1
